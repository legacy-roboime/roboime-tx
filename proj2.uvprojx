# Keil uVision project proj2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj2
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,STM32F407VG,TM_DISCO_STM32F4_DISCOVERY
  c include: ..\proj2;..\..\STM32F4_libs;..\..\STM32F4_libs\usb_cdc_device
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: defines.h main.c
  group TM
    ../../STM32F4_libs/: tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_usb_vcp.c tm_stm32f4_usb_vcp.h tm_stm32f4_nrf24l01.c tm_stm32f4_nrf24l01.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_usart.c tm_stm32f4_usart.h
  group usb_cdc_device
    ../../STM32F4_libs/usb_cdc_device/: usb_bsp.c usb_bsp.h usb_conf.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h usbd_cdc_core.c usbd_cdc_core.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_core.c usbd_core.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_req.c usbd_req.h usbd_usr.c usbd_usr.h
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
